# Keil uVision project Nixietube.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: NixieTube +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group uart
    ./: uart.h uart.c
  group oled
    ./: codetab.h oled12864.c oled12864.h I2C.c
  group delay
    ./: Delay.c Delay.h
  group dht11
    ./: DHT11.c DHT11.h
  group ds1302
    ./: DS1302.h DS1302.c
  group timer
    ./: timer.c timer.h
  group NixieTube
    ./: NixieTube.c NixieTube.h
